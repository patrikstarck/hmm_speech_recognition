<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EmbedProj_0.1.ewp</path>
    </project>
    <batchBuild />
</workspace>
